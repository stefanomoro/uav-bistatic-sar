options:
  parameters:
    author: nuc1
    generate_options: qt_gui
    id: radar_txrx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: output_dir
  id: variable
  parameters:
    value: '"/home/nuc1/uav-bistatic-sar/SDR_scripts/"'
  states: {}
- name: output_file
  id: variable
  parameters:
    value: output_dir+datetime.now().strftime("%Y-%m-%d %H-%M-%S")+ "_f"+ str(int(freq / 1e6))+ "_s" + str(int(samp_rate / 1e6))+ ".dat"
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: output_file
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: input_file
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate *duration)
    type: short
    vlen: '2'
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate *duration*1.01)
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'True'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: short
    vlen: '2'
  states: {}
- name: duration
  id: parameter
  parameters:
    label: duration in seconds
    short_id: d
    type: eng_float
    value: '30'
  states: {}
- name: freq
  id: parameter
  parameters:
    short_id: f
    type: eng_float
    value: 1.65e9
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: input_file
  id: parameter
  parameters:
    short_id: i
    type: str
    value: /home/nuc1/uav-bistatic-sar/SDR_scripts/tx_wave_56.dat
  states: {}
- name: output_file
  id: parameter
  parameters:
    value: datetime.now().strftime("%Y-%m-%d %H-%M-%S")+ "_f"+ str(int(freq / 1e6))+ "_s" + str(int(samp_rate / 1e6))+ ".dat"
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 2**15
    srate: samp_rate
    type: float
    update_time: '.5'
    ymax: 2**15
    ymin: '-2**15'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '40'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    short_id: r
    type: eng_float
    value: 45e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '40'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    minoutbuf: '100000000'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dev_args: '"num_recv_frames=1024"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    minoutbuf: '100000000'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: sc16
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_head_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_1, '0']
- [blocks_head_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
