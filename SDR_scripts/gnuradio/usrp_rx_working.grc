options:
  parameters:
    author: nuc1
    generate_options: qt_gui
    id: usrp_packet_rx_cubesat
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /mnt/ramdisk/ishort56.dat
    type: short
    vlen: '2'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2**15 * int(1e3)
    type: short
    vlen: '2'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'True'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: short
    vlen: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 2**15
    srate: samp_rate
    type: float
    update_time: '.5'
    ymax: 2**15
    ymin: '-2**15'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dev_args: num_recv_frames=1024
    gain0: '60'
    iq_imbal_enb0: '""'
    maxoutbuf: 2**13
    minoutbuf: int(1e8)
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: sc16
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_head_0, '0', blocks_file_sink_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
