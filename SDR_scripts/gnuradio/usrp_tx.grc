options:
  parameters:
    generate_options: qt_gui
    id: tx
    output_language: python
    title: tx
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: int(1.65e9)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.25'
    stop: '100'
    value: '82.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(56e6)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nuc2/Desktop/MATLAB/CODE/uav-bistatic-sar/tx_waveform/tx_waveform_gnuradio_S56M.dat
    maxoutbuf: 2**14
    minoutbuf: 2**14
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**12
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_source0: gpsdo
    dev_args: num_send_frames=1024
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
